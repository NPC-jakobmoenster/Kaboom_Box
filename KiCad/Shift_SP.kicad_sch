File: KiCad/Shift_SP.kicad_sch (KiCad schematic)
At the start: 37 parts

Commit message: First production
Parts:
- gave numbers to parts that had none: 37
